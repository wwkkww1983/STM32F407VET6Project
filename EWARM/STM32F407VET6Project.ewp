# IAR project STM32F407VET6Project.ewp, settings and files
configuration STM32F407VET6Project (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32F407xx; HSE_VALUE=8000000UL
  ICCARM.CCDiagSuppress: Pa182,Pa082,Pe177
  ICCARM.CCIncludePath2: ..\Drivers\CMSIS\Include; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Src; ..\STARTUP\EWARM; ..\Complier; ..\Doc; ..\STM32F4xx; ../Application/AD5593; ../Application/ADC; ../Application/ADS8688; ../Application/APP; ../Application/AT24Cxx; ../Application/CRC; ../Application/Delay; ../Application/DHT11; ../Application/DS18B20; ../Application/EEPROM; ../Application/FLASH; ../Application/GPIO; ../Application/HMC830; ../Application/I2C; ../Application/IAP; ../Application/ISP; ../Application/IWDG; ../Application/Key; ../Application/LED; ../Application/LCD1602; ../Application/OneWire; ../Application/PCF8563; ../Application/Power; ../Application/Random; ../Application/RFASK; ../Application/SPI; ../Application/SysTick; ../Application/Timer; ../Application/USART; ../Application/WM8510; ../Application/NRF2401; ..\Application\OLED; ..\Application\WWDG; ..\Application\SHT2x; ..\Application\BKP; ..\Application\CSS; ..\Application\Decode; ..\Application\W25Qxx; ..\Application\DS1302; ..\Application\RFASKHW; ..\Application\ENC28J60; ..\Application\PID; ..\Application\ADS1256; ..\Application\PVD; ..\Application\RTC; ..\Application\MyMalloc; ..\Application\HMC472; ..\Application\ADS868x; ..\Application\ADS869x; ..\Application\DAC
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Main.hex
  postbuild: "$TOOLKIT_DIR$\bin\ielftool.exe" --bin --verbose  "$TARGET_PATH$" "$TARGET_BPATH$.bin"
  ILINK.IlinkOutputFile: STM32F407VET6Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/AD5593
    ../Application/AD5593/: ad5593_cfg.c ad5593_cfg.h ad5593_lib.c ad5593_lib.h ad5593_task.c ad5593_task.h
  group Application/ADC
    ../Application/ADC/: adc_cfg.c adc_cfg.h adc_lib.c adc_lib.h adc_task.c adc_task.h
  group Application/ADS1256
    ../Application/ADS1256/: ads1256_cfg.c ads1256_cfg.h ads1256_lib.c ads1256_lib.h ads1256_task.c ads1256_task.h
  group Application/ADS868x
    ../Application/ADS868x/: ads868x_cfg.c ads868x_cfg.h ads868x_lib.c ads868x_lib.h ads868x_task.c ads868x_task.h
  group Application/ADS869x
    ../Application/ADS869x/: ads869x_cfg.c ads869x_cfg.h ads869x_lib.c ads869x_lib.h ads869x_task.c ads869x_task.h
  group Application/APP
    ../Application/APP/: config.h main.c main.h
  group Application/AT24Cxx
    ../Application/AT24Cxx/: at24cxx_cfg.c at24cxx_cfg.h at24cxx_lib.c at24cxx_lib.h at24cxx_task.c at24cxx_task.h
  group Application/BKP
    ../Application/BKP/: bkp_cfg.c bkp_cfg.h bkp_lib.c bkp_lib.h bkp_task.c bkp_task.h
  group Application/CRC
    ../Application/CRC/: crc_cfg.c crc_cfg.h crc_lib.c crc_lib.h crc_task.c crc_task.h
  group Application/CSS
    ../Application/CSS/: css_cfg.c css_cfg.h css_lib.c css_lib.h css_task.c css_task.h
  group Application/DAC
    ../Application/DAC/: dac_cfg.c dac_cfg.h dac_lib.c dac_lib.h dac_task.c dac_task.h
  group Application/Decode
    ../Application/Decode/: decode_cfg.c decode_cfg.h decode_lib.c decode_lib.h decode_task.c decode_task.h
  group Application/Delay
    ../Application/Delay/: delay_cfg.c delay_cfg.h delay_lib.c delay_lib.h delay_task.c delay_task.h
  group Application/DHT11
    ../Application/DHT11/: dht11_cfg.c dht11_cfg.h dht11_lib.c dht11_lib.h dht11_task.c dht11_task.h
  group Application/DS1302
    ../Application/DS1302/: ds1302_cfg.c ds1302_cfg.h ds1302_lib.c ds1302_lib.h ds1302_task.c ds1302_task.h
  group Application/DS18B20
    ../Application/DS18B20/: ds18b20_cfg.c ds18b20_cfg.h ds18b20_lib.c ds18b20_lib.h ds18b20_task.c ds18b20_task.h
  group Application/EEPROM
    ../Application/EEPROM/: eeprom_cfg.c eeprom_cfg.h eeprom_lib.c eeprom_lib.h eeprom_task.c eeprom_task.h
  group Application/FLASH
    ../Application/FLASH/: flash_cfg.c flash_cfg.h flash_lib.c flash_lib.h flash_task.c flash_task.h
  group Application/GPIO
    ../Application/GPIO/: gpio_cfg.c gpio_cfg.h gpio_lib.c gpio_lib.h gpio_task.c gpio_task.h
  group Application/HMC830
    ../Application/HMC830/: hmc830_cfg.c hmc830_cfg.h hmc830_lib.c hmc830_lib.h hmc830_task.c hmc830_task.h
  group Application/I2C
    ../Application/I2C/: i2c_cfg.c i2c_cfg.h i2c_lib.c i2c_lib.h i2c_task.c i2c_task.h
  group Application/IAP
    ../Application/IAP/: iap_cfg.c iap_cfg.h iap_lib.c iap_lib.h iap_task.c iap_task.h
  group Application/ISP
    ../Application/ISP/: isp_cfg.c isp_cfg.h isp_lib.c isp_lib.h isp_task.c isp_task.h
  group Application/IWDG
    ../Application/IWDG/: iwdg_cfg.c iwdg_cfg.h iwdg_lib.c iwdg_lib.h iwdg_task.c iwdg_task.h
  group Application/Key
    ../Application/Key/: key_cfg.c key_cfg.h key_lib.c key_lib.h key_task.c key_task.h
  group Application/LCD1602
    ../Application/LCD1602/: lcd1602_cfg.c lcd1602_cfg.h lcd1602_lib.c lcd1602_lib.h lcd1602_task.c lcd1602_task.h
  group Application/LED
    ../Application/LED/: led_cfg.c led_cfg.h led_lib.c led_lib.h led_task.c led_task.h
  group Application/MyMalloc
    ../Application/MyMalloc/: my_malloc.c my_malloc.h
  group Application/NRF2401
    ../Application/NRF2401/: nrf2401_cfg.c nrf2401_cfg.h nrf2401_lib.c nrf2401_lib.h nrf2401_task.c nrf2401_task.h
  group Application/OLED
    ../Application/OLED/: oled_cfg.c oled_cfg.h oled_lib.c oled_lib.h oled_task.c oled_task.h
  group Application/OneWire
    ../Application/OneWire/: one_wire_cfg.c one_wire_cfg.h one_wire_lib.c one_wire_lib.h one_wire_task.c one_wire_task.h
  group Application/PCF8563
    ../Application/PCF8563/: pcf8563_cfg.c pcf8563_cfg.h pcf8563_lib.c pcf8563_lib.h pcf8563_task.c pcf8563_task.h
  group Application/PID
    ../Application/PID/: pid_cfg.c pid_cfg.h pid_lib.c pid_lib.h pid_task.c pid_task.h
  group Application/PVD
    ../Application/PVD/: pvd_cfg.c pvd_cfg.h pvd_lib.c pvd_lib.h pvd_task.c pvd_task.h
  group Application/Random
    ../Application/Random/: random_cfg.c random_cfg.h random_lib.c random_lib.h random_task.c random_task.h
  group Application/RFASK
    ../Application/RFASK/: rfask_cfg.c rfask_cfg.h rfask_lib.c rfask_lib.h rfask_task.c rfask_task.h
  group Application/RFASKHW
    ../Application/RFASKHW/: rfaskhw_cfg.c rfaskhw_cfg.h
  group Application/RTC
    ../Application/RTC/: rtc_cfg.c rtc_cfg.h rtc_lib.c rtc_lib.h rtc_task.c rtc_task.h
  group Application/SHT2x
    ../Application/SHT2x/: sht2x_cfg.c sht2x_cfg.h sht2x_lib.c sht2x_lib.h sht2x_task.c sht2x_task.h
  group Application/SPI
    ../Application/SPI/: spi_cfg.c spi_cfg.h spi_lib.c spi_lib.h spi_task.c spi_task.h
  group Application/SysTick
    ../Application/SysTick/: systick_cfg.c systick_cfg.h systick_lib.c systick_lib.h systick_task.c systick_task.h
  group Application/Timer
    ../Application/Timer/: timer_cfg.c timer_cfg.h timer_lib.c timer_lib.h timer_task.c timer_task.h
  group Application/USART
    ../Application/USART/: usart_cfg.c usart_cfg.h usart_lib.c usart_lib.h usart_task.c usart_task.h
  group Application/W25Qxx
    ../Application/W25Qxx/: w25qxx_cfg.c w25qxx_cfg.h w25qxx_lib.c w25qxx_lib.h w25qxx_task.c w25qxx_task.h
  group Application/WM8510
    ../Application/WM8510/: wm8510_cfg.c wm8510_cfg.h wm8510_lib.c wm8510_lib.h wm8510_task.c wm8510_task.h
  group Application/WWDG
    ../Application/WWDG/: wwdg_cfg.c wwdg_cfg.h wwdg_lib.c wwdg_lib.h wwdg_task.c wwdg_task.h
  group Complier
    ../Complier/: complier_cfg.c complier_cfg.h complier_lib.c complier_lib.h
  group Doc
    ../Doc/: ReadMe.txt
  group Drivers/CMSIS
    ../STM32F4xx/: system_stm32f4xx.c system_stm32f4xx.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_utils.c
    ../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_def.h stm32f4xx_hal_gpio.h stm32f4xx_hal_rcc.h stm32f4xx_ll_adc.h stm32f4xx_ll_bus.h stm32f4xx_ll_cortex.h stm32f4xx_ll_crc.h stm32f4xx_ll_dac.h stm32f4xx_ll_dma.h stm32f4xx_ll_dma2d.h stm32f4xx_ll_gpio.h stm32f4xx_ll_i2c.h stm32f4xx_ll_iwdg.h stm32f4xx_ll_pwr.h stm32f4xx_ll_rcc.h stm32f4xx_ll_rng.h stm32f4xx_ll_rtc.h stm32f4xx_ll_spi.h stm32f4xx_ll_system.h stm32f4xx_ll_tim.h stm32f4xx_ll_usart.h stm32f4xx_ll_utils.h
  group STARTUP/EWARM
    ../STARTUP/EWARM/STM32F4/: startup_stm32f407xx.s
  group STM32F4xx
    ../STM32F4xx/: stm32_assert.h stm32_cfg.c stm32_cfg.h stm32f407xx.h stm32f4xx.h stm32f4xx_hal_conf.h stm32f4xx_it.c stm32f4xx_it.h stm32f4xx_ll.h
